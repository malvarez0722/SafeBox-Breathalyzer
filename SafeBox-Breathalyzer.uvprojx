# Keil uVision project SafeBox-Breathalyzer.uvprojx, settings and files
target SafeBox (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: SafeBox-Breathalyzer
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: .\Objects\SafeBox-Breathalyzer.sct
  group src
    ./src/: Blynk.c Latch.c DAC.c esp8266.c Music.c ST7735.c PLL.c PortF.c Timer0A.c Timer2.c Timer3.c Timer4A.c Timer5A.c UART.c SafeBox.c startup.s PWM.c PWMtest.c CortexM.c
  group inc
    ./inc/: Latch.h DAC.h esp8266.h Music.h ST7735.h PLL.h PortF.h Timer0A.h Timer2.h Timer3.h Timer4A.h Timer5A.h tm4c123gh6pm.h UART.h PWM.h CortexM.h
software components: CMSIS:CORE 5.2.0
